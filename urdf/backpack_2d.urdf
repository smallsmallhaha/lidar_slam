Commit message: add cartographer default configuration

File: urdf/backpack_2d.urdf (robot description, URDF)
Before this commit: robot cartographer_backpack_2d, 4 links, 3 joints
Joints:
- joint horizontal_laser_link_joint: origin xyz=0.02 0.02 -0.035 -> xyz=0.1007 0 0.0558
